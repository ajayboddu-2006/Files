* C:\Users\Ajay\eSim-Workspace\FlashADC\FlashADC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 04/03/25 21:25:44

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ Net-_U2-Pad6_ Net-_U2-Pad7_ Net-_U2-Pad8_ Net-_U2-Pad9_ Net-_U2-Pad10_ Net-_U2-Pad11_ priorityencoder
X1  ? Net-_R2-Pad1_ Vin Net-_X1-Pad4_ ? Net-_U3-Pad1_ Net-_X1-Pad7_ ? lm_741
X2  ? Net-_R2-Pad2_ Vin Net-_X1-Pad4_ ? Net-_U3-Pad2_ Net-_X1-Pad7_ ? lm_741
X3  ? Net-_R3-Pad2_ Vin Net-_X1-Pad4_ ? Net-_U3-Pad3_ Net-_X1-Pad7_ ? lm_741
X4  ? Net-_R4-Pad2_ Vin Net-_X1-Pad4_ ? Net-_U3-Pad4_ Net-_X1-Pad7_ ? lm_741
X5  ? Net-_R5-Pad2_ Vin Net-_X1-Pad4_ ? Net-_U3-Pad5_ Net-_X1-Pad7_ ? lm_741
X6  ? Net-_R6-Pad2_ Vin Net-_X1-Pad4_ ? Net-_U3-Pad6_ Net-_X1-Pad7_ ? lm_741
X7  ? Net-_R1-Pad2_ Vin Net-_X1-Pad4_ ? Net-_U3-Pad7_ Net-_X1-Pad7_ ? lm_741
v2  Net-_X1-Pad7_ GND 12
v1  GND Net-_X1-Pad4_ 12
v3  Net-_R2-Pad1_ GND 7
R2  Net-_R2-Pad1_ Net-_R2-Pad2_ 1k
R3  Net-_R2-Pad2_ Net-_R3-Pad2_ 1k
R4  Net-_R3-Pad2_ Net-_R4-Pad2_ 1k
R5  Net-_R4-Pad2_ Net-_R5-Pad2_ 1k
R6  Net-_R5-Pad2_ Net-_R6-Pad2_ 1k
R7  Net-_R6-Pad2_ Net-_R1-Pad2_ 1k
R1  GND Net-_R1-Pad2_ 1k
U3  Net-_U3-Pad1_ Net-_U3-Pad2_ Net-_U3-Pad3_ Net-_U3-Pad4_ Net-_U3-Pad5_ Net-_U3-Pad6_ Net-_U3-Pad7_ GND Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ Net-_U2-Pad6_ Net-_U2-Pad7_ Net-_U2-Pad8_ adc_bridge_8
U4  Net-_U2-Pad9_ Net-_U2-Pad10_ Net-_U2-Pad11_ B2 B1 B0 dac_bridge_3
U5  B2 plot_v1
U6  B1 plot_v1
U7  B0 plot_v1
U1  Vin plot_v1
v4  Vin GND sine

.end
